VERSION 5.8 ;
MACRO PRTOOL_COB
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 100.0 BY 100.0 ;
END PRTOOL_COB

MACRO PRTOOL_TOB
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 400.0 BY 200.0 ;
END PRTOOL_TOB

MACRO PRTOOL_HCHAN
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 500.0 BY 50.0 ;
END PRTOOL_HCHAN

MACRO PRTOOL_VCHAN
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 50.0 BY 500.0 ;
END PRTOOL_VCHAN

END LIBRARY
